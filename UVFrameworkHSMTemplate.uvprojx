# Keil uVision project UVFrameworkHSMTemplate.uvprojx, settings and files
target BaseFrameworkTarget (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: BaseTarget
  AfterMake: fromelf --bin --output .\Outputs\@L.bin .\Outputs\@L.axf
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_TM4C123_RB1
  c misc: --c99
  c include: C:\ti\TivaWare_C_Series-2.1.0.12573;.\Headers
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
  group Main
    ./Source/: HSMTemplateMain.c
  group Source
    ./Source/: EventCheckers.c MapKeys.c HSMTemplate.c TopHSMTemplate.c Master_SM.c CapturePS_SM.c PACLogic_SM.c Request_SM.c Helpers.c SendingByte_SM.c SendingCMD_SM.c AttackStrategy_SM.c HallEffect_SM.c Attack_SM.c TemplateService.c PositionLogic_Service.c PhotoTransistor_Service.c PWM_Service.c DriveTrainControl_Service.c CannonControl_Service.c PeriscopeControl_Service.c EnemyCaptureQueue.c Strategy_SM.c GameInfo.c EnablePA25_PB23_PD7_PF0.c
  group Headers
    ./Headers/: uartstdio.h Bin_Const.h BITDEFS.H ES_CheckEvents.h ES_Configure.h ES_DeferRecall.h ES_Events.h ES_Framework.h ES_General.h ES_LookupTables.h ES_Port.h ES_PostList.h ES_PriorTables.h ES_Queue.h ES_ServiceHeaders.h ES_Timers.h ES_Types.h EventCheckers.h termio.h HSMTemplate.h TopHSMTemplate.h MapKeys.h DEFINITIONS.h Master_SM.h CapturePS_SM.h PACLogic_SM.h Request_SM.h SendingByte_SM.h SendingCMD_SM.h Attack_SM.h AttackStrategy_SM.h TemplateService.h PositionLogic_Service.h PWMFlywheel_Service.h Helpers.h PWMHopper_Service.h PWMPeriscope_Service.h PWMCannonAngle_Service.h PWMPowerTrain_Service.h PhotoTransistor_Service.h DriveTrainControl_Service.h CannonControl_Service.h PeriscopeControl_Service.h Strategy_SM.h
  group Libraries
    C:/ti/TivaWare_C_Series-2.1.0.12573/driverlib/rvmdk/: driverlib.lib
  group Startup
    ./StartUp/: startup_rvmdk.S
  group Framework
    ./Source/: ES_CheckEvents.c ES_DeferRecall.c ES_Framework.c ES_LookupTables.c ES_Port.c ES_PostList.c ES_Queue.c ES_Timers.c retarget.c termio.c uartstdio.c
